## config/boards/shields/zmk_5x5numpads/Kconfig.defconfig
```kconfig
if SHIELD_ZMK_K1_NUMS

config ZMK_KEYBOARD_NAME
    default "zmk_k1_nums"

endif
```
